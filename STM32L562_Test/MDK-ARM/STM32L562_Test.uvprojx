# Keil uVision project STM32L562_Test.uvprojx, settings and files
target STM32L562_Test (6140001::V6.14.1::ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: STM32L562_Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32L562xx
  c include: ../Core/Inc;../Drivers/STM32L5xx_HAL_Driver/Inc;../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../Drivers/CMSIS/Include
  scatter file: stm32l562xe_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32l562xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dfsdm.c fmc.c i2c.c icache.c usart.c octospi.c sai.c sdmmc.c spi.c tim.c ucpd.c usb.c stm32l5xx_it.c stm32l5xx_hal_msp.c
  group Drivers/STM32L5xx_HAL_Driver
    ../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_ll_utils.c stm32l5xx_ll_exti.c stm32l5xx_hal_adc.c stm32l5xx_hal_adc_ex.c stm32l5xx_hal.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_icache.c stm32l5xx_hal_dfsdm.c stm32l5xx_hal_dfsdm_ex.c stm32l5xx_ll_fmc.c stm32l5xx_hal_sram.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_ospi.c stm32l5xx_hal_sai.c stm32l5xx_hal_sai_ex.c stm32l5xx_ll_sdmmc.c stm32l5xx_hal_sd.c stm32l5xx_hal_sd_ex.c stm32l5xx_hal_spi.c stm32l5xx_hal_spi_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_ll_ucpd.c stm32l5xx_ll_gpio.c stm32l5xx_ll_dma.c stm32l5xx_hal_pcd.c stm32l5xx_hal_pcd_ex.c stm32l5xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l5xx.c
software components: CMSIS:CORE 4.3.0
